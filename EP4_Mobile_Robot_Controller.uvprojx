# Keil uVision project EP4_Mobile_Robot_Controller.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ESS Lab 4 Keypad
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c RCServo.c RCServo.h startup_stm32f303xe.s Stepper.c Stepper.h stm32f303xe.h SysClock.c SysClock.h system_stm32f3xx.c UART.c UART.h Utility.c Utility.h LED.c LED.h PushButton.c PushButton.h KeyPad.c KeyPad.h Ultrasonic.c Ultrasonic.h DCMotor.c DCMotor.h LCD.h
software components: CMSIS:CORE 5.6.0
